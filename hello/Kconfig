## hello/Kconfig
```kconfig
config HELLO
tristate "Hello Driver added by bing"
default n
help
    test for adding driver to menuconfig.
```
